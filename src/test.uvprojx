# Keil uVision project test.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c clock.c clock.h gpio.c gpio.h ir_sensors.c ir_sensors.h motors.c motors.h pwm.c pwm.h buzzer.c buzzer.h delay.c delay.h subsystemInit.c subsystemInit.h ADC.c ADC.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
